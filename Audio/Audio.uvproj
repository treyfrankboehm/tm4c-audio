# Keil uVision project Audio.uvproj, settings and files
target Audio Target (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Audio
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Audio Source
    ./: startup.s dac.c dac.h tm4c123gh6pm.h lookup.c lookup.h timers.c timers.h pll.c pll.h paradigm.h percussion.c percussion.h main.c pitch_macros.h Comm.h Comm.c
