# Keil uVision project Game.uvproj, settings and files
target Game Target (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Game
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ....\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC.c pll.c ST7735.c SysTickInts.c ADC.h LCD.h pll.h ST7735.h SysTickInts.h tm4c123gh6pm.h LCD.s startup.s Game_Background_4.h main.c Draw_Sprite.c Draw_Sprite.h globals.c timers.c timers.h Calculate.c Song.c Screens.c
